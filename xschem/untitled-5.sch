v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {PLL_FOLDER/pfd.sym} 210 -100 0 0 {name=x1}
C {PLL_FOLDER/cp/cp.sym} 600 -100 0 0 {name=x2}
