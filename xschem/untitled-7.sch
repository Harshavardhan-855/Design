v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {PLL_FOLDER/cp/cp_schem.sym} 250 -40 0 0 {name=x1}
