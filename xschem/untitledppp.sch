v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {PLL_FOLDER/pfd.sym} 180 -100 0 0 {name=x1}
C {PLL_FOLDER/cp/cp_schem.sym} 470 -180 0 0 {name=x2}
