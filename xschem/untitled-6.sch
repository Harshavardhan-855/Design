v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {PLL_FOLDER/cp/cp.sym} -80 -30 0 0 {name=x1}
