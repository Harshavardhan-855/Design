v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {cs_amplifier.sym} 130 20 0 0 {name=x1}
